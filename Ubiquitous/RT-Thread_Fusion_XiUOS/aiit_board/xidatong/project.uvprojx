# Keil uVision project project.uvprojx, settings and files
target rtthread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052CVL5B, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;board;board\MCUX_Config;board\ports;..\..\rt-thread\bsp\imxrt\libraries\drivers;..\..\rt-thread\bsp\imxrt\libraries\drivers\config;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\devfs;..\..\rt-thread\components\finsh;.;..\..\rt-thread\include;..\..\rt-thread\components\libc\compilers\armlibc;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\libc\compilers\common\nogcc;..\..\rt-thread\components\libc\posix\pthreads;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\CMSIS\Include;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\MIMXRT1052;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\MIMXRT1052\drivers;..\..\..\..\APP_Framework\Applications\general_functions\list;..\..\..\..\APP_Framework\Framework\knowing\ota;..\..\..\..\APP_Framework\Framework\sensor;..\..\..\..\APP_Framework\Applications;..\..\..\..\APP_Framework\Framework\sensor\altitude\bmp180;..\..\..\..\APP_Framework\Framework\sensor\co2\g8s;..\..\..\..\APP_Framework\Framework\sensor\voice\d124;..\..\..\..\APP_Framework\Framework\sensor\winddirection\qs-fx;..\..\..\..\APP_Framework\Framework\sensor\windspeed\qs-fs;..\..\..\..\APP_Framework\Framework\transform_layer\rtthread;..\..\rt-thread\examples\utest\testcases\kernel;xip
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Applications
    applications/: main.c
  group CPU
    ../../rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c context_rvds.S cpuport.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/cputime/: cputime.c
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/src/: completion.c waitqueue.c ringbuffer.c ringblk_buf.c workqueue.c pipe.c dataqueue.c
  group Drivers
    board/MCUX_Config/: pin_mux.c clock_config.c
    board/: board.c
    ../../rt-thread/bsp/imxrt/libraries/drivers/: drv_sdram.c drv_gpio.c drv_uart.c
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../rt-thread/src/: memheap.c idle.c timer.c mempool.c components.c ipc.c device.c clock.c thread.c irq.c scheduler.c object.c kservice.c
  group libc
    ../../rt-thread/components/libc/compilers/armlibc/: stdio.c syscalls.c mem_std.c libc.c
    ../../rt-thread/components/libc/compilers/common/: unistd.c delay.c time.c stdlib.c
    ../../rt-thread/components/libc/posix/pthreads/: mqueue.c pthread_cond.c semaphore.c pthread_barrier.c sched.c pthread_rwlock.c pthread_attr.c pthread_spin.c pthread_mutex.c pthread_tls.c pthread.c
  group Libraries
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/drivers/: fsl_gpio.c fsl_lpuart.c fsl_semc.c fsl_clock.c fsl_cache.c fsl_common.c
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group list
    ../../../../APP_Framework/Applications/general_functions/list/: double_list.c single_list.c
  group sensor
    ../../../../APP_Framework/Applications/: framework_init.c
  group transform
    ../../../../APP_Framework/Framework/transform_layer/rtthread/: transform.c
  group xip
    xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_flash.c
